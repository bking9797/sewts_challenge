Commit message: world link added to urdf

File: src/CRX-10iA_L/urdf/CRX-10iA_L.urdf (robot description, URDF)
Before this commit: robot CRX-10iA_L, 7 links, 6 joints
Links:
- added link world
Joints:
- added joint base_joint: type fixed, parent world, child base_link, origin xyz=0 0 0 rpy=0 0 0
